File: kicad/alleycat_outline.kicad_pcb (KiCad board)
At the start: 2 copper layers, 138.5 x 126 mm, 0 parts

Commit message: better outline
Other:
- board size 138.5 x 126 mm -> 144 x 131 mm
